<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Circuitscope_FW.ewp</path>
  </project>
  <batchBuild />
</workspace>
